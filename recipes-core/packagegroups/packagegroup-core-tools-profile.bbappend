LTTNGUST=""
LTTNGTOOLS=""
LTTNGMODULES=""