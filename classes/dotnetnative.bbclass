EXTRANATIVEPATH += "dotnet-native"
DEPENDS_append = " dotnet-native "